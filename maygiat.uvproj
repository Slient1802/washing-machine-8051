# Keil uVision project maygiat.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: maygiat +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Port.h
    D:/Project/washing-machine-8051/: Delay.c Main.c Seven_segment.c SOES.c Switch.c Washer.c
